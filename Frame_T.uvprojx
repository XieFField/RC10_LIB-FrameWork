# Keil uVision project Frame_T.uvprojx, settings and files
target Frame_T (6240000::V6.24::ARMCLANG)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.2
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Frame_T +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=8 wLevel=1
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7 ARM_MATH,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: -finput-charset=UTF-8
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../RC10_LIB/BSP_Driver/Inc;../RC10_LIB/Motor/Inc;../RC10_LIB/APP/Inc;../User/Control/Inc;../User/debug/Inc;../User/Setup/Inc;../RC10_LIB/Module/Inc;../Middlewares/ST/ARM/DSP/Inc;../Drivers/CMSIS/DSP/Include;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  asm include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.cpp gpio.c freertos.c dma.c fdcan.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group RC10_LIB/APP
    ../RC10_LIB/APP/Inc/: APP_PID.h APP_tool.h APP_CoordConvert.h APP_Speedplanner.h APP_Vector2D.h APP_Bezier_Curve.h APP_debugTool.h APP_Path.h
    ../RC10_LIB/APP/Src/: APP_PID.cpp APP_tool.cpp APP_CoordConvert.cpp APP_Speedplanner.cpp APP_Vector2D.cpp APP_Path.cpp
  group RC10_LIB/Module
    ../RC10_LIB/Module/Src/: Module_Encoder.cpp Module_ChassisBase.cpp Module_Air_joy.cpp Module_ChassisOmni.cpp Module_GPIO.cpp Module_Position.cpp
    ../RC10_LIB/Module/Inc/: Module_ChassisBase.h Module_Encoder.h Module_Air_joy.h Module_ChassisOmni.h Module_GPIO.h Module_Position.h
  group RC10_LIB/BSP
    ../RC10_LIB/BSP_Driver/Src/: BSP_fdCAN_Driver.cpp BSP_TimeStamp.cpp retarget_io.cpp BSP_USB_UART_Driver.cpp
    ../RC10_LIB/BSP_Driver/Inc/: BSP_fdCAN_Driver.h BSP_CanFrame.h BSP_RTOS.h BSP_TimeStamp.h BSP_USB_UART_Driver.h
  group RC10_LIB/Motor
    ../RC10_LIB/Motor/Inc/: Motor_Base.h Motor_DJI.h Motor_VESC.h Motor_DM.h
    ../RC10_LIB/Motor/Src/: Motor_DJI.cpp Motor_VESC.cpp Motor_DM.cpp
  group User/debug
    ../User/debug/Inc/: frame_demo.h arm_demo.h debug_setup.h speedplanner_demo.h
    ../User/debug/Src/: frame_demo.cpp arm_demo.cpp speedplanner_demo.cpp
  group User/Control
    ../User/Control/Inc/: Robot_Arm.h PathPlanner.h PathTracing.h AutoCtrler.h
    ../User/Control/Src/: Robot_Arm.cpp PathPlanner.cpp PathTracing.cpp AutoCtrler.cpp
  group User/Setup
    ../User/Setup/Inc/: Setup_ConfigInit.h FSM_Controller.h Arm_Setup.h FSMstauts_enum.h omni_chassisSetup.h
    ../User/Setup/Src/: Setup_ConfigInit.cpp FSM_Controller.cpp Arm_Setup.cpp omni_chassisSetup.cpp
  group CMSIS/DSP
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM7lfsp_math.lib
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 6.1.0
